# Keil uVision project StarTower.uvproj, settings and files
target StarTower_T5L (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: StarTower +hex
  c flags: Optimize=3
  c include: ..\USER;..\FUNC_HANDLER;..\GUI_APP;..\HANDWARE\DHT11;..\HANDWARE
  asm include: D:\keil5\C51\INC\
  link misc: REMOVEUNUSED
  group StarTower
    ./: main.c tower.c levels.c view.c audio.c sys.c STARTUP_M5.A51
